export XDG_CONFIG_HOME = "${DL_DIR}/.config"
export XDG_DATA_HOME = "${DL_DIR}/.data"
export USERPROFILE = "${DL_DIR}/.userprofile"
export PSEUDO_PREFIX = "${STAGING_DIR_NATIVE}/usr"
