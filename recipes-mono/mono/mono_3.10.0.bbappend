FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://enable-profile4_5-scripts.patch"
