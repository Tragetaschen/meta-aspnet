require libuv.inc

SRC_URI[md5sum] = "2f6260ce13601da925a49dad43098db4"
SRC_URI[sha256sum] = "5f12b66942d9df302c826c869fed1aabc1959fced8c67cdd8c0e2a98c1185b42"
