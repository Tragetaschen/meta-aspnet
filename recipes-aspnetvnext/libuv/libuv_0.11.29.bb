require libuv.inc

SRC_URI[md5sum] = "907dafd14c78d5490c2b8796a3ea9edf"
SRC_URI[sha256sum] = "fac45e72c2df30ddc9cbdf5002fc1363281d0e433831e3d43acb1036c2cabfc6"
