require libuv.inc

SRC_URI[md5sum] = "c5e4bbf954b8438c57d9414ee54b4d90"
SRC_URI[sha256sum] = "9e4852f5fb430ce66a9b23d1bbf2e65ac2cd63873742f18edbc59e213260e1b0"
