SERVER_URI="https://www.myget.org/F/aspnetvnext/api/v2"

require kre-bin.inc

SRC_URI[kre.md5sum] = "9e280c4249c323a4c0f86dbd774c487a"
SRC_URI[kre.sha256sum] = "12913bd14bcc7a3bdee8ecd2fa50e859f9a484e8535e692d7a962aed8a68bd65"
