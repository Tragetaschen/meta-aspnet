require kre-bin.inc

SRC_URI[kre.md5sum] = "c2ddeb0f2a991bd3e87e5c5c696aec70"
SRC_URI[license.md5sum] = "18d62531c894e91f9f01b5146b73468d"
SRC_URI[kre.sha256sum] = "f45e926a9d3343c6295be0a1bbb2f7a9465af350e3cfc97cabf1ea6f35b08cbe"
SRC_URI[license.sha256sum] = "3b8b4437035351a81b3b808172c5c4133eafd86480ee41a67a080ee973dc3897"
