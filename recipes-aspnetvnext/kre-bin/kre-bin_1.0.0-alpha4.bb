require kre-bin.inc

SRC_URI[kre.md5sum] = "c8810ee917c4604118a375eee1a608a2"
SRC_URI[kre.sha256sum] = "55d8e9e40b1e2b340329e759128b4e362621bb99d9eadee14d1bba7fc080656d"
