SERVER_URI="https://www.myget.org/F/aspnetmaster/api/v2"

require kre-bin.inc

SRC_URI[kre.md5sum] = "a8a38bd9b974d31973d61325e12615a9"
SRC_URI[kre.sha256sum] = "4d84a303b1ebfdd766b303085b90d5ee72c718783cb5af452e19dc617185808e"
