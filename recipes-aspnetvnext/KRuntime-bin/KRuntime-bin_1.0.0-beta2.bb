require KRuntime-bin.inc

SRC_URI[kre.md5sum] = "927109312c51a41af2c1a910f24761c0"
SRC_URI[kre.sha256sum] = "4184e91bc70c9f1f7caea8883622f86b95777e6db73d360c7b6ba1cafe9f100e"
