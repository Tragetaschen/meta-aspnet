require KRuntime-bin.inc

SRC_URI[kre.md5sum] = "4f5f378e924541ec22ddbb64bba3f25e"
SRC_URI[kre.sha256sum] = "53a3c327a01386dd3f4c3596518e7138ce062933423ba8b5ca49e521ef699b75"
