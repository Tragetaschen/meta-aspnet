include helloworld-vnext.inc

SRC_URI[md5sum] = "3c5913aa876a3ad51b0f86fe8072cfcf"
SRC_URI[sha256sum] = "bd4fe776be109733abb5f8a87b8b4b72e765f5fcd2c1a54dea06555bb9b1bded"

