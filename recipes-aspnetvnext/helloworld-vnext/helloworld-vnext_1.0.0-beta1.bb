include helloworld-vnext.inc

SRC_URI[md5sum] = "592aba1f08866f86f552c2d7ad91f733"
SRC_URI[sha256sum] = "27eb1bbfa3b567393678a1d2f3618b7f52894605b4c88c8a71d68ef55ba804b9"

