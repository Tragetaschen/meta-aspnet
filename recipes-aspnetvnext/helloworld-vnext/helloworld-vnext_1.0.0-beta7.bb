include helloworld-vnext.inc

SRC_URI[md5sum] = "cf5390ffd8b0c79d8dbc99ce55c2e065"
SRC_URI[sha256sum] = "5aa3dc6edc3313ce74ac4b7901446f56f1b2848939adcfcc3fca4469bd88b4de"

