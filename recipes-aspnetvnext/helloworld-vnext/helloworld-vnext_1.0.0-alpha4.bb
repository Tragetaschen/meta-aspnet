include helloworld-vnext.inc

SRC_URI[md5sum] = "2357280e2193b00f2aa416f440f88d69"
SRC_URI[sha256sum] = "8b081faad278eb76060fb75dd974b72214c2630e561d8cdeca2e21de2438da1f"

