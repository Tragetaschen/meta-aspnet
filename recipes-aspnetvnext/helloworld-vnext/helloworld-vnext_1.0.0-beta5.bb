include helloworld-vnext.inc

SRC_URI[md5sum] = "3ec5eeb3a3bb4e3f2dbbafbf43cde13e"
SRC_URI[sha256sum] = "6230054f4b119859cd8257308835da4ecdeefb7c4b4f05613ec7f4c766a2246e"

