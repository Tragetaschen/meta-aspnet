include helloworld-vnext.inc

SRC_URI[md5sum] = "cf0dcb1187b63fd3adac310e27640e79"
SRC_URI[sha256sum] = "90a35fae4d7793c28d4e97802e07c4c6133b314a0be77457dab7492795dca7de"

