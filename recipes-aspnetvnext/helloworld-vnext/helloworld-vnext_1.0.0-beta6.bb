include helloworld-vnext.inc

SRC_URI[md5sum] = "56ce7943bdbd88eae18bf9c85fc4dc18"
SRC_URI[sha256sum] = "5cbda50b4831c3084284d8198d355bd12b80e18399c2a5533859652ab3ac8c02"

