include helloworld-vnext.inc

SRC_URI[md5sum] = "01d960959def93ccb2138c74c0c9af34"
SRC_URI[sha256sum] = "e915f3d742516ea1de98f854827d9ac85dca50db9d1d0a672b0bf7a10d0f4eaa"

