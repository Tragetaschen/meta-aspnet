include helloworld-vnext.inc

SRC_URI[md5sum] = "5b2bc75f50c556c4eac93e0abe7b1e70"
SRC_URI[sha256sum] = "6197122c78e209f5473256ae3bb56c198c088a22d9fa412ba0c7bc6cddf6eba8"

