include home-consoleapp-vnext.inc

SRC_URI[md5sum] = "40cc2fc8d3fbaf5ea361c7d82230c1da"
SRC_URI[sha256sum] = "c6362e8c83952c21f2ffcc40d51e1fc2f93c7de3b6a80ae5be800e8f88a33fd5"

