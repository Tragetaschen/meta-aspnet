include home-consoleapp-vnext.inc

SRC_URI[md5sum] = "7ba8d860361ee37520a9f055f3555ee7"
SRC_URI[sha256sum] = "2ea3af428ea8f6affdcf4c25fe3607550bd02f642a017537f741a0e7947b9f15"

