include home-consoleapp-vnext.inc

SRC_URI[md5sum] = "b76df5d2e930437c7884a48e4aa03d8b"
SRC_URI[sha256sum] = "4f51c3cab798d59d729caa5caf013126ec2b3a5bc0175802b0e07803c3cdfe15"

