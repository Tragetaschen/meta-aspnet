include home-consoleapp-vnext.inc

SRC_URI[md5sum] = "8691095d85c4eee499388ffd4b31d761"
SRC_URI[sha256sum] = "a60c324e818b1c5fa8b96a98783c69028a89cba9f1c46c69f14f44359c48ce4c"

