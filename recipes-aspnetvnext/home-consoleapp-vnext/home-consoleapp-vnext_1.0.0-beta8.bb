include home-consoleapp-vnext.inc

SRC_URI[md5sum] = "0ef804425c669806faf4abb4cb6e3f35"
SRC_URI[sha256sum] = "dc42d5a37b1ed257b65b6d27f7217ad7efb9ea1c12c3755f0d5ceedd9d141998"

