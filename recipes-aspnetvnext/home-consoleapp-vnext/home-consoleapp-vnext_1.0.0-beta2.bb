include home-consoleapp-vnext.inc

SRC_URI[md5sum] = "b81eb88d00a931a5c9577a05a00a299a"
SRC_URI[sha256sum] = "e00835e19109a22f2820de0cbe34cbaac5f2e6becc2b90c8cc996b1d9dbe50f6"

