include home-consoleapp-vnext.inc

SRC_URI[md5sum] = "50671dcf72c7883ac42b098bf1dc0d25"
SRC_URI[sha256sum] = "6824052244614e77197a205cd3a4a2d79fc662ae8397d096817068a4409d229c"

