include home-consoleapp-vnext.inc

SRC_URI[md5sum] = "177c431731b1151d90ed90c419acfcbb"
SRC_URI[sha256sum] = "e1121b330029868f8252f0ceef257020c511a6c898d06d699210d1539a2d45c8"

