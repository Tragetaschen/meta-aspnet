include home-consoleapp-vnext.inc

SRC_URI[md5sum] = "bf37feae4eb1c437794e5ca18468c0ed"
SRC_URI[sha256sum] = "36af1ff02b706e146564f9fb40dec3c7042c85872056d5678f9ca885ff65d0f5"

