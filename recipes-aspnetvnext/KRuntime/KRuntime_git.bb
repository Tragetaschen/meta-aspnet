SRC_URI="git://github.com/aspnet/KRuntime.git;branch=dev"
SRCREV = "${AUTOREV}"
S = "${WORKDIR}/git"

include KRuntime.inc
