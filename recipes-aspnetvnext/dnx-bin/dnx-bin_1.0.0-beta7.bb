require dnx-bin.inc

SRC_URI[dnx.md5sum] = "bed3fa426bc8652a166cd59d84f773c1"
SRC_URI[dnx.sha256sum] = "1087f051fdc84f9c792f15ee70ada3265a5ea6aa322b0d993499063d957bb1b7"
