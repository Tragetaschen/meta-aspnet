require dnx-bin.inc

SRC_URI[dnx.md5sum] = "cfb1ce6b6f708f9e3c27c2510ece002e"
SRC_URI[dnx.sha256sum] = "2a6f17cf597fbf3e42243379006e00518891c412db20ebaf9828da68322cddbb"
