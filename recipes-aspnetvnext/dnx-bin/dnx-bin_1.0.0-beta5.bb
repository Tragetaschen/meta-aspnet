require dnx-bin.inc

SRC_URI[dnx.md5sum] = "bb72e5c5a172a7ffee499f027b55cd3e"
SRC_URI[dnx.sha256sum] = "bcc8c83c8e0313c93271f63fadb0dee32d1a1898fb2c46aa41a828907887dd82"
