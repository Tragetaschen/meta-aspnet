require dnx-bin.inc

SRC_URI[dnx.md5sum] = "c2bfceed6e00c2d6bab27c80b79d4399"
SRC_URI[dnx.sha256sum] = "33972d2631cbf0f742e4624157ecd626f02c80b8dd7caabd850a267e3cfe1fd9"
