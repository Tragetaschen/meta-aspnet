require dnx-bin.inc

SRC_URI[dnx.md5sum] = "4116093f8988dd768e978ac9dff7e8c4"
SRC_URI[dnx.sha256sum] = "0d28a1b44695d5b65eadef4f93de091a9bad713abc761775650e19c79d8f25ae"
