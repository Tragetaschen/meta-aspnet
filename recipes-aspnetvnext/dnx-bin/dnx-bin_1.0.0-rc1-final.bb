require dnx-bin.inc

SRC_URI[dnx.md5sum] = "c5e7c7b3d0519f20849ec1d485c5740a"
SRC_URI[dnx.sha256sum] = "6ea51b0049d2065de412f8264eb6475990f1852c9df645f38a2a6fe4bd2c14d6"
