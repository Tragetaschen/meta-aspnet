require dnx-bin.inc

SRC_URI[dnx.md5sum] = "e90e606129677bb636317cec5db599e2"
SRC_URI[dnx.sha256sum] = "4cc49514e1a6d975b062e0fc773192abcddac02269cfc462cdd1f3e074ee1cc8"
