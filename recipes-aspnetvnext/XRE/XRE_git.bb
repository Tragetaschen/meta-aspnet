SRC_URI="git://github.com/aspnet/XRE.git;branch=dev"
SRCREV = "${AUTOREV}"
S = "${WORKDIR}/git"

include XRE.inc
