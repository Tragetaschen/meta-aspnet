COREFX_SRCREV="v${PV}"
COREFX_BUILD_MAJOR="25519"
COREFX_BUILD_MINOR="03"

include corefx.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=9fc642ff452b28d62ab19b7eea50dfb9"
