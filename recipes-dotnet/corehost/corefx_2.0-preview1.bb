include preview1-revs.inc
include corefx.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=9fc642ff452b28d62ab19b7eea50dfb9"
